# Repository tmcit-ararobo-2026a/logic-power-management-board

## KiCad design logic-power-management-board/logic-power-management-board.kicad_pcb

Parts:
C1, C2, C3: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C13: 1000μF35V; CP_Radial_D12.5mm_P5.00mm
C5, C7, C8, C9, C10, C11, C12: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC1: MCP2562; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1, J2, J3: Conn_01x02; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J4, J5: Conn_01x02; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J7, J8: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J9: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1, Q2, Q3: RS6L120BGTB1; SOP_Advance
R1, R3, R5, R7: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R6, R8, R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; switch_TVAF06-A020B-R
SW2: SW_SPDT_312; CJS1200A1
U1, U2, U3: LM5050-1; TSOT-23-6
U4: NJM12888F33; SOT-23-5_HandSoldering
U5: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm

Connections:
+3.3V: C6.1, C7.1, C8.1, C9.1, C12.1, IC1.5 (VIO), J6.4, J9.2, R16.1, U4.5 (VOUT), U5.1 (VDD), U5.15 (VDDA), U5.17 (VDD)
+5V: C5.1, C11.1, IC1.3 (VCC), J7.3, J8.3, R15.1, U4.1 (VIN), U4.3 (CONTROL)
ADC1_CH1: R1.1, R2.2, U5.5 (PA0)
ADC1_CH2: R3.1, R4.2, U5.6 (PA1)
ADC1_CH3: R5.1, R6.2, U5.7 (PA2)
ADC1_CH4: R7.1, R8.2, U5.8 (PA3)
CANH: IC1.7 (CANH), J7.4, J8.4, R10.1
CANL: IC1.6 (CANL), J7.2, J8.2, SW2.2 (B)
CAN_RX: IC1.4 (RXD), U5.21 (PA11)
CAN_TX: IC1.1 (TXD), U5.22 (PA12)
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), IC1.2 (GND), IC1.8 (S), J1.1, J2.1, J3.1, J4.1, J5.1, J6.2, J7.1, J8.1, J9.4, R2.1, R4.1, R6.1, R8.1, R9.1, SW1.1, U1.2 (GND), U1.3 (OFF), U2.2 (GND), U2.3 (OFF), U3.2 (GND), U3.3 (OFF), U4.2 (GND), U5.14 (VSSA), U5.16 (VSS), U5.32 (VSS)
IN1: C1.1, J1.2, Q1.3 (S), R1.2, R17.1, U1.4 (IN)
IN2: C2.1, J2.2, Q2.3 (S), R3.2, R18.1, U2.4 (IN)
IN3: C3.1, J3.2, Q3.3 (S), R5.2, R19.1, U3.4 (IN)
LED1: R11.1, U5.9 (PA4)
LED2: R12.1, U5.10 (PA5)
LED3: R13.1, U5.11 (PA6)
LED4: R14.1, U5.12 (PA7)
NRST: C10.1, SW1.2, U5.4 (PG10)
unnamed: D1.2 (A), R11.2
unnamed: D2.2 (A), R12.2
unnamed: D3.2 (A), R13.2
unnamed: D4.2 (A), R14.2
unnamed: D5.2 (A), R15.2
unnamed: D6.2 (A), R16.2
unnamed: D7.2 (A), R17.2
unnamed: D8.2 (A), R18.2
unnamed: D9.2 (A), R19.2
unnamed: D10.2 (A), R20.2
unnamed: Q1.1 (G), U1.5 (GATE)
unnamed: Q2.1 (G), U2.5 (GATE)
unnamed: Q3.1 (G), U3.5 (GATE)
unnamed: R10.2, SW2.1 (A)
unnamed: R9.2, U5.31 (PB8)
OUT: C4.1, C13.1, J4.2, J5.2, Q1.2 (D), Q2.2 (D), Q3.2 (D), R7.2, R20.1, U1.1 (VS), U1.6 (OUT), U2.1 (VS), U2.6 (OUT), U3.1 (VS), U3.6 (OUT)
SWCLK: J6.3, U5.24 (PA14)
SWDIO: J6.1, U5.23 (PA13)
UART_RX: J9.1, U5.30 (PB7)
UART_TX: J9.3, U5.29 (PB6)

Notes on the sheet:
UPS用理想ダイオード回路
CAN
LED
stm32
CANトランシーバー
STLink
UART
リセットSW

Board: 2 copper layers, 60.0 x 70.0 mm, 63 parts (2 on the bottom side), 39 nets.

File logic-power-management-board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3",0603,3,0.1uf,
"C10, C11, C12, C5, C7, C8, C9",0603,7,0.1u,
"C13, C4",CP_Radial_D12.5mm_P5.00mm,2,1000μF35V,
C6,0603,1,0.47u,
"D1, D10, D2, D3, D4, D5, D6, D7, D8, D9",0603,10,LED,
IC1,SOIC127P600X175-8N,1,MCP2562,
"J1, J2, J3",AMASS_XT60PW-M_1x02_P7.20mm_Horizontal,3,Conn_01x02,
"J4, J5",AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,2,Conn_01x02,
J6,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
"J7, J8",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,2,Conn_01x04,
J9,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,Conn_01x04,
"Q1, Q2, Q3",SOP_Advance,3,RS6L120BGTB1,
"R1, R3, R5, R7",0603,4,100k,
R10,0603,1,120,
"R11, R12, R13, R14, R15, R16, R17, R18, R19, R20",0603,10,1k,
"R2, R4, R6, R8, R9",0603,5,10k,
SW1,switch_TVAF06-A020B-R,1,SW_Push,
SW2,CJS1200A1,1,SW_SPDT_312,
"U1, U2, U3",TSOT-23-6,3,LM5050-1,
U4,SOT-23-5_HandSoldering,1,NJM12888F33,
U5,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,

## KiCad design switchboard/switchboard.kicad_pcb

Parts:
C1: 0.33uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D3: GS1010FL; SOD-123FL
D2: SS2040FL; SOD-123FL
D4: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x02; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: Conn_01x02; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
K1: G8ND-2-DC12SK; G8ND2DC12SK; Mouser Part Number 653-G8ND-2-DC12SK
R1, R2, R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push_LED; LS601-CRwithCAP
U1: NJM7812SDL1; TO-252-2

Connections:
+12V: C2.1, D1.2 (A), D3.2 (A), K1.6 (COIL_2), K1.7 (COIL_3), U1.3 (VOUT)
GND: C1.2, C2.2, D1.1 (K), D3.1 (K), D4.1 (K), J1.1, J2.1, K1.5 (COIL_1), K1.8 (COIL_4), R1.2, R2.2, U1.2 (GND)
unnamed: C1.1, D2.1 (K), SW1.2, SW1.4 (A), U1.1 (VIN)
unnamed: D4.2 (A), R3.1
unnamed: K1.1 (NC), R1.1
unnamed: R2.1, SW1.3 (K)
OUT: D2.2 (A), J2.2, K1.2 (COM_1), K1.3 (COM_2)
VCC: J1.2, K1.4 (NO), R3.2, SW1.1

Board: 2 copper layers, 80.0 x 40.0 mm, 14 parts (0 on the bottom side), 8 nets.

File switchboard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,0.33uf,
C2,0603,1,1uf,
"D1, D3",SOD-123FL,2,GS1010FL,
D2,SOD-123FL,1,SS2040FL,
D4,0603,1,LED,
J1,AMASS_XT60PW-M_1x02_P7.20mm_Horizontal,1,Conn_01x02,
J2,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,Conn_01x02,
K1,G8ND2DC12SK,1,G8ND-2-DC12SK,
"R1, R2, R3",0603,3,10k,
SW1,LS601-CRwithCAP,1,SW_Push_LED,
U1,TO-252-2,1,NJM7812SDL1,

## Code that names these connections

File logic-power-management-board.ioc (part):

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Mcu.Name=STM32G431K(6-8-B)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32G431K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=ADC_CH1
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=ADC_CH2
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=ADC_CH3
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=ADC_CH4
PA3.Mode=IN4-Single-Ended
PA3.Signal=ADC1_IN4
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=LED1
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED2
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=LED3
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=LED4
PA7.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=128000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-04-18 回路図完成
2026-04-18 FETの向きが逆だったので修正
2026-04-19 PCB完成(ビア、シルクを除く)
2026-04-19 コンデンサー追加、シルク修正
2026-04-22 switchboardの追加
2026-04-25 ガーバ生成
2026-04-25 配線、ビアの修正
